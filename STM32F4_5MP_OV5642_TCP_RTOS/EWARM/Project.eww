<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F4_5MP_OV5642_TCP_RTOS.ewp</path>
  </project>
  <batchBuild />
</workspace>
